<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pwm using tivac.ewp</path>
    </project>
    <batchBuild />
</workspace>
